<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Jun 25 13:14:18 2025</timestamp>
			<uuid>{904f6645-732d-41ca-828c-dbc8d195cffa}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/lxusers/c/crgrace/projects/65nm/NeuROC/workspace_lbnl/design/virtuoso/cadence_libs/cg_PLL/pll_cp_tb/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/lxusers/c/crgrace/projects/65nm/NeuROC/workspace_lbnl/design/virtuoso/cadence_libs/cg_PLL/pll_cp_tb/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/lxusers/c/crgrace/simulation/cg_PLL/pll_cp_tb/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/cg_PLL/pll_cp_tb/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
